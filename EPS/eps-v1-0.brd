# Repository spaceconcordia/Consat1Electrical (continued)

## EAGLE design Payload External/payload-externalPCB-version2-modif2.brd

Parts:
C1: 10 uF; C1210
C2: 0.033 uF; C0805
C3, C4, C5, C6, C7, C10, C11, C12, C19, C20, C21, C22, C23, C24, C30, C31, C32, C33, C34, C35: 100 uF; C1210
C8: C-EUC1210; C1210
C9: C-USC0805; C0805
C13, C14, C25, C26: 0.01 uF; C1206
C15, C16: 2.2 uF; C2220K
C18: 15 pF; C0805
C36, C37: 1 uF; C2220K
R1, R12: 4.75 MOhm; R1206
R2: 10 Ohm; R2010
R3: 179 Ohm; R2010
R4: 1MOhm; R2010
R5: 4 MOhm; R2010
R6, R18: 47 kOhm; R1210
R7, R17: 4.87 kOhm; R2010
R8: 100 kOhm; R2010
R9: 102 kOhm; R1206
R10: 43.1 kOhm; R2010
R11: 4.87 kOhm; R1210
R13, R14, R15, R16: R-US_R2010; R2010
R19: 1.2 MOhm; R1206
R20: 4.85 kOhm; R2010
U$1: M80-5000000M2-04-331-00-000
U$2, U$3: M80-8670805
U$4, U$9: IRLIZ14GPBF-ND-SCHEMATICS; TO-220FULLPAK-IRLIZ14GPBF-ND
U$5, U$10: PM61300-4-RC
U$6, U$15, U$16, U$23: PZT3904-SOT223-SCHEMATICS; SOT223-PZT3904
U$7, U$8, U$11, U$12: S1J-SCHEMATICS; DO-214AC-S1J
U$13, U$14: RESISTOR-J-LEAD-5W; PACKAGE-13573-J-LEAD
U$17, U$18, U$19, U$20, U$21, U$22: SMBJ5388B-ZENER-DIODE-200V; DO-214AA-SMBJ5388B-ZENER

Connections:
5V: R10.2, U$3.P$1, U$15.P$1 (C), U$16.P$1 (C), U$23.P$1 (C)
G-M-CATHODE: R8.2, R19.2, U$1.P$2
G-M-COUNTS: R10.1, U$2.P$3, U$6.P$1 (C)
G-M-OUTPUT: U$1.P$3
G-M-OUTPUT-AMPLITUDE: R20.1, U$2.P$8, U$23.P$4 (E)
GND1: C1.2, C8.2, R2.1, R4.1, R6.1, R7.1, R13.1, R15.1, R17.1, R18.1, R20.2, U$3.P$2, U$4.P$1 (S), U$9.P$1 (S)
GND2: C3.2, C4.2, C5.2, C6.2, C7.2, C10.2, C11.2, C12.2, C14.2, C15.2, C16.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C26.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, R5.1, R9.1, R11.1, R16.1, U$3.P$3, U$8.P$1 (A), U$12.P$1 (A), U$19.P$1, U$22.P$1
GND3: U$3.P$4, U$6.P$4 (E)
HV_G-M-ANODE1: C14.1, C15.1, C36.1, R1.2, R5.2, U$1.P$1, U$7.P$2 (C), U$17.P$2
HV_G-M-ANODE2: C16.1, C26.1, C37.1, R12.2, R16.2, U$1.P$4, U$11.P$2 (C), U$20.P$2
HV_OUTPUT1: R7.2, U$2.P$5, U$15.P$4 (E)
HV_OUTPUT2: R17.2, U$2.P$6, U$16.P$4 (E)
unnamed: R3.1, U$4.P$3 (G)
unnamed: U$17.P$1, U$18.P$2
unnamed: C13.1, U$5.10
unnamed: C13.2, U$7.P$1 (A), U$8.P$2 (C)
unnamed: R12.1, R18.2, U$16.P$2 (B)
unnamed: C3.1, C4.1, C5.1, C6.1, C7.1, C11.1, C12.1, C19.1, C20.1, C21.1, U$5.6
unnamed: U$5.3, U$13.P$2
unnamed: C2.2, R2.2
unnamed: C10.1, C22.1, C23.1, C24.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, U$10.6
unnamed: C2.1, U$4.P$2 (D), U$13.P$1
unnamed: R14.1, U$9.P$3 (G)
unnamed: C9.2, R13.2
unnamed: U$10.3, U$14.P$2
unnamed: C9.1, U$9.P$2 (D), U$14.P$1
unnamed: R1.1, R6.2, U$15.P$2 (B)
unnamed: C25.1, U$10.10
unnamed: C25.2, U$11.P$1 (A), U$12.P$2 (C)
unnamed: U$18.P$1, U$19.P$2
unnamed: U$20.P$1, U$21.P$2
unnamed: U$21.P$1, U$22.P$2
unnamed: C18.1, R8.1, R11.2, U$6.P$2 (B)
unnamed: R9.2, R19.1, U$23.P$2 (B)
PULSE1: R3.2, R4.2, U$2.P$1
PULSE2: R14.2, R15.2, U$2.P$7
VOLTAGE_SWEEP1: C1.1, U$2.P$2, U$5.1
VOLTAGE_SWEEP2: C8.1, U$2.P$4, U$10.1

Board: 4 copper layers, 94.8 x 83.0 mm, 76 parts (1 on the bottom side), 37 nets.

## EAGLE design Payload External/Payload_exterior v1.0.brd

Parts:
C11, C15, C16, C17: 0.01uF; C050-035X075
C12: 10uF; C050-035X075
C14: 100uF; C050-035X075
D5, D6, D7, D8: 1N4007; DO41-10
D9, D10: ZTE; DO35Z10
L1: 10mH; 0207/12
Q2: 2N4403; TO92-CBE
R13, R16: 1K; 0207/12
R14: 150K; 0207/12
R15: 100K; 0207/12
T1: MPSA42; TO92-ECB
T2: MPSA18; TO92-ECB
VIN: SSW-101-02-S-D
VOUT: SSW-101-02-S-D

Connections:
GND: C14.2, C15.2, C17.2, VIN.2, VOUT.2
unnamed: C12.1, Q2.E, R16.2
unnamed: C11.2, Q2.B, R14.1, R15.2, T2.C
unnamed: D5.A, R13.2, R15.1, R16.1
unnamed: C16.1, D5.C, D6.A, L1.1, T1.C
unnamed: C12.2, R14.2, T1.E
unnamed: C15.1, D6.C, D8.A, D10.C
unnamed: C16.2, D7.A, D8.C
unnamed: C17.1, D7.C, VOUT.1
unnamed: Q2.C, T1.B
unnamed: C11.1, D9.A, T2.B
unnamed: D9.C, D10.A
V_IN: C14.1, L1.2, R13.1, T2.E, VIN.1

Board: 2 copper layers, 64.8 x 59.4 mm, 22 parts (0 on the bottom side), 13 nets.

File Payload External/Payload_exterior v1.0 bom.csv:

"Part";"Value";"Device";"Package";"Description";"MF";"MPN";"OC_FARNELL";"OC_NEWARK";
"C11";"0.01uF";"C-US050-035X075";"C050-035X075";"CAPACITOR, American symbol";"";"";"";"";
"C12";"10uF";"C-US050-035X075";"C050-035X075";"CAPACITOR, American symbol";"";"";"";"";
"C14";"100uF";"C-US050-035X075";"C050-035X075";"CAPACITOR, American symbol";"";"";"";"";
"C15";"0.01uF";"C-US050-035X075";"C050-035X075";"CAPACITOR, American symbol";"";"";"";"";
"C16";"0.01uF";"C-US050-035X075";"C050-035X075";"CAPACITOR, American symbol";"";"";"";"";
"C17";"0.01uF";"C-US050-035X075";"C050-035X075";"CAPACITOR, American symbol";"";"";"";"";
"D5";"1N4007";"1N4004";"DO41-10";"DIODE";"";"";"";"";
"D6";"1N4007";"1N4004";"DO41-10";"DIODE";"";"";"";"";
"D7";"1N4007";"1N4004";"DO41-10";"DIODE";"";"";"";"";
"D8";"1N4007";"1N4004";"DO41-10";"DIODE";"";"";"";"";
"D9";"ZTE";"ZTE";"DO35Z10";"Z DIODE";"";"";"";"";
"D10";"ZTE";"ZTE";"DO35Z10";"Z DIODE";"";"";"";"";
"L1";"10mH";"L-US0207/12";"0207/12";"INDUCTOR, American symbol";"";"";"";"";
"Q2";"2N4403";"2N4126";"TO92-CBE";"PNP Transistror";"";"";"";"";
"R13";"1K";"R-US_0207/12";"0207/12";"RESISTOR, American symbol";"";"";"";"";
"R14";"150K";"R-US_0207/12";"0207/12";"RESISTOR, American symbol";"";"";"";"";
"R15";"100K";"R-US_0207/12";"0207/12";"RESISTOR, American symbol";"";"";"";"";
"R16";"1K";"R-US_0207/12";"0207/12";"RESISTOR, American symbol";"";"";"";"";
"T1";"MPSA42";"2SC458";"TO92-ECB";"NPN Silicon Epitaxial Planar Transistor";"";"";"";"";
"T2";"MPSA18";"2SC458";"TO92-ECB";"NPN Silicon Epitaxial Planar Transistor";"";"";"";"";
"VIN";"SSW-101-02-S-D";"SSW-101-02-S-D";"SSW-101-02-S-D";"THROUGH-HOLE .025" SQ POST SOCKET";"";"SSW-101-02-S-D";"unknown";"82P1456";
"VOUT";"SSW-101-02-S-D";"SSW-101-02-S-D";"SSW-101-02-S-D";"THROUGH-HOLE .025" SQ POST SOCKET";"";"SSW-101-02-S-D";"unknown";"82P1456";

## Commit log

2015-08-10 Initial commit, the drawings are for Consat1, Build #2, November 2013
    Changes to be committed:
    new file: .gitignore
    new file: ACS/ACS_PCB.GBL
    new file: ACS/ACS_PCB.GBO
    new file: ACS/ACS_PCB.GBS
    new file: ACS/ACS_PCB.GTL
2015-08-14 Removed payload exterior v1; This design did not meet the voltage requirements
    On branch cs1benchsat
    Changes to be committed:
    deleted: Payload External/Payload_exterior v1.0.brd
    deleted: Payload External/Payload_exterior v1.0.cmp
    deleted: Payload External/Payload_exterior v1.0.drd
    deleted: Payload External/Payload_exterior v1.0.dri
2015-08-14 Directory rename CDH-V3.7 -> CDH
2015-08-14 Updates to CDH subsystem
    Changes to be committed:
    deleted: CDH-v3.7.pro
    deleted: CDH-v3.7_PCB_Final_Design.pdf
    renamed: CDH-v3.7.brd -> CDH-v4.1.brd
    new file: CDH-v4.1.pro
    renamed: CDH-v3.7.sch -> CDH-v4.1.sch
2015-08-14 Further updates to CDH Added design v2 of the payload external pcb
    Changes to be committed:
    deleted: CDH/CDH-v4.1.brd
    deleted: CDH/CDH-v4.1.pro
    new file: CDH/CDH-v4.11-A-DS1338-tcc-test-redesign.brd
    renamed: CDH/CDH-v4.1.sch -> CDH/CDH-v4.11-A-DS1338-tcc-test-redesign.sch
    new file: Payload External/payload-externalPCB-version2-modif2.brd
2015-08-14 Added working version of v2 payload external schematic Added Libraries dir
    Changes to be committed:
    new file: Libraries/space-concordia-power.lbr
    modified: Payload External/payload-externalPCB-version2-modif2.brd
    modified: Payload External/payload-externalPCB-version2-modif2.sch
2015-08-25 Generated BOMs for ACS, CDH, Diplexer and Payload Ext/Payload Int
    Changes to be committed:
    new file: ACS/ACS PCB bom.csv
    new file: CDH-V3.7/CDH-v3.7 bom.csv
    new file: Diplexer/diplexer_v4rev0-bom.csv
    new file: Payload External/Payload_exterior v1.0 bom.csv
    new file: Payload Internal - Auxiliary/Payload v2.1 bom.csv
2015-08-26 Started updating wiring harness to include bottom 1u db25 wiring
2015-08-29 updating wiring harness as per "20131201 - Continuity Check" test
2015-08-30 Updated Payload internal schem with notes from "20131201 - Continuity Check" Added connections to wiring harness schematic as per "20131201 - Continuity Check"
2015-08-31 added directory for eagle lbrs working on bottom 1u wiring harness according to solar panel bom and "20131201 - Continuity Check"
2015-08-31 - finished bottom 1u wiring harness as per "20131201 - Continuity Check"
2015-08-31 Including consat1 grounding arch diagram
2015-09-03 renaming Libraries to eagle naming convention
2015-09-04 pulled in the updated wiring harness from cs1bld2 branch
2015-09-04 pulled in updates in libraries, internal payload schematic, grounding arch and BOMs from cs1bld2 branch
2015-09-04 brought in version 1.1 of the EPS
2015-09-10 updated internal payload schematic to v3.6
2015-09-17 Updated grounding diagram: Added external payload block Updated all payload blocks with more grounding connectors
2015-09-17 Updated notes on grounding diagram
2015-09-28 Updated some header descriptions and labels
2015-09-28 merged in updates from cs1dev branch for: wiring harness acs and diplexer boms lbr (eagle libraries)
2015-09-30 Added antenna and ACS to grounding diagram
2015-10-27 worked on the wiring harness: - fixed some signals between ext payload and int payload - added wire data.ods sheet
    ran 'snap to grid' on internal payload schematic
2015-11-15 Wiring Harness - review and update wire data spreadsheet with Pierre-Lucas - review and update schematic to track spreadsheet
    misc
    - updated gitignore to ignore libreoffice locks
2015-11-18 CDH updates - renamed H1 <-> H2 headers to match others schematics - deleted misleading 'Q6_GPIO_10' label
    Wiring harness updates
    - deleted misleading 'Q6_GPIO_10' label
2015-12-19 updated schematic metadata
2016-02-23 [Wiring Harness] matched connector type and nets for ACS <-> wiring-harness
    [MISC] converted the start of schematic convention doc to .MD
2016-02-23 [MISC] fixed formatting on ELEC_SCHEMATIC_CONVENTIONS doc
2016-02-24 [CDH] renamed connectors to 'J#' in sync with wiring harness [diplexer-rcl.lbr] copied rcl.lbr and created an inductor with SMD package L01005(imperial) [DIPLEXER] renamed sma connectors to 'J#' in s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
2016-04-22 Fixed all the trivial wiring issues for the CDH, Diplexer, EPS and wiring harness schematics
2016-04-26 [CDH] updated trivial mismatches between connector netnames [EPS] updated trivial mismatches between connector netnames [PAYLOAD] updated trivial mismatches between connector netnames [WIRING] update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
2016-05-01 [PAYLOAD-INT] added h2 pin 26 and pin 28 short (to match actual PCB)
2016-05-01 Revert "Fixed all the trivial wiring issues for the CDH, Diplexer, EPS and wiring harness schematics"
    This reverts commits
    6713d85a6277b26f983fd7a52d0f95a7f9e4e046.
    086194ae58682b6763f31692a26cd4dac33df983
    82b42737f0fe6cd82dfea4a4ae7507beb01cc7b8
    This revert is required because changing/connecting net names in eagle will automatically modify or destroy PCB traces associated with those netnames.
    Updating the schematics and PCBs will need to be redone carefully to ensure no traces are destroyed.
2016-05-01 [DIPLEXER] - updated netnames to match wiring harness netnames [WIRING] - updated parts J10,J11 and J12 to match the correct coax connector used on the diplexer
2016-05-01 [CDH] - fixed typos in signal netnames so they match wiring-harness - updated 'EXTERNAL_POWER_+V' and 'EXTERNAL_POWER_GND' so that they match the EPS header [WIRING] - updated 'EXTERNAL_POWER_+V' and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
2016-07-05 [CDH] [Wiring Harness] [Payload-Internal-Aux] renamed nets 'Q6_PC_RS232' and 'PC_Q6_RS232' to 'Q6_MAX_RS232' and 'MAX_Q6_RS232' for clarity
2016-07-07 [Wiring Harness] [Payload-Internal-Aux] Renamed unconnected header pins to match wiring harness. The remaining conflicts are legitimate wired net conflicts and can only be resolved with redesign.
2016-07-13 [Payload-Internal-Aux] During 20160705 unit testing it was noticed that pin9(vcc) and pin10(!forceoff) were shorted. Updated schematic to match.
2016-07-14 [EPS] Added and modified netnames of unused header pins and unconflicted netnames to match the wiring schematic netnames The remaining conflicts are legitimate wired net conflicts, or grounding confl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
