# Repository spaceconcordia/Consat1Electrical

File README.md:

# Consat1Electrical

Eagle schematics for all custom electrical designs and wiring harnesses for Space Concordias Consat1 project

http://spaceconcordia.ca

## EAGLE design EPS/eps-v1-0.brd

Parts:
C1: 1.8nF; C0805
C2: 47pF; C0805
C3, C6, C7: 100pF; C0805
C4: 150uF; D/7343-31R
C5: 2.2nF; C0805
C8, C11, C12: 10uF; D/7343-31R
C9, C10, C13, C14, C15, C16, C20: 0.1uF; C0805
C19: 1uF; C0805
D1, D2, D3, D4: PMEG3050EP; SOD128
H1, H2: ESQ-125-XX-X-D
IC1, IC2: MIC79110; MLF10-EP
IC3, IC4: LT3872; TSOT23-8
IC5: INA291-D; SO08
IC6, IC7: NCS2202; SOT23-5
IC8: TLV70233DBVR; SOT23-5
IC9: AD7998; TSSOP-20
IC10: MAX4374-10UMAX; 10UMAX
IC11: TLV70228DBV; SOT23-5
L1: DR125-180; DR125
L2: DR125-470; DR125
Q1, Q2, Q3, Q9: SI7448DP; PPAK-SO08-EP
Q4, Q6, Q8: SI7485DP; PPAK-SO08-EP
R1, R31: 63.4k; M1206
R2, R25: 549k; M1206
R3, R26: 200k; M1206
R4: 17.4k; M1206
R5, R6, R11, R24, R28, R38, R39: 20k; M1206
R7: 23.2k; M1206
R8: 10k; M1206
R9: 64.9k; M1206
R10, R27: 221k; M1206
R12: 100k; M1206
R13: 0.01; M1206
R14, R15: 10; M1206
R16, R20: 2k; M1206
R17, R21: 340; M1206
R18, R22: 3.4Meg; M1206
R19, R23, R33, R35: 1Meg; M1206
R29: 147k; M1206
R30: 133k; M1206
R32: 53.6k; M1206
R34, R36: 2Meg; M1206
R37: 0.03; M1206
U$1: EPS_PCB_THRM_PAD

Connections:
ANTENNA_DEPLOYMENT_+V: H1.1, Q6.P$5-D (D), Q6.P$6-D (D), Q6.P$7-D (D), Q6.P$8-D (D), Q6.P$9-D (D), Q6.P$10-D (D), Q6.P$11-D (D)
BATTERY_HEATER_+V: H1.4, IC1.P$3 (SNS), IC1.P$4 (BAT), IC2.P$3 (SNS), IC2.P$4 (BAT), IC11.1 (VIN), IC11.3 (ENA), Q4.P$1-S (S), Q4.P$2-S (S), Q4.P$3-S (S), Q6.P$1-S (S), Q6.P$2-S (S), Q6.P$3-S (S), Q8.P$1-S (S), Q8.P$2-S (S), Q8.P$3-S (S), R6.2, R13.2, R14.2, R18.2, R22.2, R24.2, R39.2
BATTERY_HEATER_-V: H1.6, Q3.P$5-D (D), Q3.P$6-D (D), Q3.P$7-D (D), Q3.P$8-D (D), Q3.P$9-D (D), Q3.P$10-D (D), Q3.P$11-D (D), Q9.P$5-D (D), Q9.P$6-D (D), Q9.P$7-D (D), Q9.P$8-D (D), Q9.P$9-D (D), Q9.P$10-D (D), Q9.P$11-D (D)
BATTERY_THRMSTOR2_+V: H1.12, IC7.3 (+IP), IC9.P$14 (VIN_2), R2.1
BATTERY_THRMSTOR_+V: H1.8, IC6.3 (+IP), IC9.P$13 (VIN_4), R25.1
BOTTOM_TEMP_SOLAR_PANEL-1: H2.9
BOTTOM_TEMP_SOLAR_PANEL-2: H2.11
BOTTOM_TEMP_SOLAR_PANEL-3: H2.13
BOTTOM_TEMP_SOLAR_PANEL-4: H2.15
ELEC_BAY_TEMP_1: H2.50
EXTERNAL_POWER_+V: H1.35, H2.52, R13.1, R15.2
GNDA: C1.2, C2.2, C3.2, C4.-, C5.2, C6.2, C7.2, C8.-, C9.2, C10.2, C11.-, C12.-, C14.2, C15.2, C16.2, C19.2, C20.2, H1.3, H1.10, H1.37, H1.41, H1.45, H1.49, H2.17, H2.19, H2.33, H2.51, IC1.P$7 (ACHG), IC1.P$10 (GND), IC2.P$7 (ACHG), IC2.P$10 (GND), IC3.P$1 (IPRG), IC3.P$4 (GND), IC4.P$4 (GND), IC5.1 (A1), IC5.2 (A0), IC5.6 (GND), IC6.5 (VEE), IC7.5 (VEE), IC8.2 (GND), IC9.P$1 (AGND), IC9.P$3 (AGND), IC9.P$4 (AGND), IC9.P$7 (VIN_1), IC9.P$8 (VIN_3), IC9.P$9 (VIN_5), IC9.P$10 (VIN_7), IC9.P$15 (AS), IC9.P$16 (/CONVST), IC9.P$20 (AGND), IC10.P$5 (GND), IC10.P$6 (/RST), IC11.2 (GND), Q1.P$1-S (S), Q1.P$2-S (S), Q1.P$3-S (S), Q2.P$1-S (S), Q2.P$2-S (S), Q2.P$3-S (S), Q3.P$1-S (S), Q3.P$2-S (S), Q3.P$3-S (S), Q9.P$1-S (S), Q9.P$2-S (S), Q9.P$3-S (S), R5.1, R8.1, R10.1, R12.1, R16.1, R17.1, R19.1, R20.1, R21.1, R23.1, R27.1, R31.1, R32.1, R33.2, R35.2
MAX_Q6_RS232: H1.21
MECH_DEPLOY_SWITCH_+V: H1.30, H1.31, H1.33, H2.31
unnamed: C10.1, C11.+, D4.P$1-CATHODE, IC4.P$1 (IPRG), IC4.P$6 (VIN), L1.P$1 (1)
unnamed: IC4.P$3 (VFB), R1.1, R5.2
unnamed: C1.1, R4.1
unnamed: D1.P$2-ANODE, IC4.P$8 (SW), L1.P$2 (2), Q1.P$5-D (D), Q1.P$6-D (D), Q1.P$7-D (D), Q1.P$8-D (D), Q1.P$9-D (D), Q1.P$10-D (D), Q1.P$11-D (D)
unnamed: D2.P$2-ANODE, IC3.P$8 (SW), L2.P$2 (2), Q2.P$5-D (D), Q2.P$6-D (D), Q2.P$7-D (D), Q2.P$8-D (D), Q2.P$9-D (D), Q2.P$10-D (D), Q2.P$11-D (D)
unnamed: IC3.P$5 (NGATE), Q2.P$4-G (G)
unnamed: IC3.P$3 (VFB), R8.2, R9.1
unnamed: C5.1, R7.1
unnamed: C6.1, IC3.P$2 (ITH), R7.2
unnamed: C9.1, C12.+, D3.P$1-CATHODE, IC3.P$6 (VIN), L2.P$1 (1)
unnamed: IC9.P$11 (VIN_8), R35.1, R36.2
unnamed: IC2.P$2 (RSET), R17.2
unnamed: D3.P$2-ANODE, Q8.P$5-D (D), Q8.P$6-D (D), Q8.P$7-D (D), Q8.P$8-D (D), Q8.P$9-D (D), Q8.P$10-D (D), Q8.P$11-D (D)
unnamed: IC2.P$9 (REOC), R16.2
unnamed: IC1.P$2 (RSET), R21.2
unnamed: C4.+, D1.P$1-CATHODE, IC10.P$10 (RS+), R1.2, R37.2
unnamed: IC1.P$1 (SD), IC1.P$8 (DEOC), R22.1, R23.2
unnamed: IC1.P$9 (REOC), R20.2
unnamed: IC7.1 (OP), Q3.P$4-G (G), R11.1
unnamed: IC7.4 (-IP), R3.1, R10.2
unnamed: IC9.P$12 (VIN_6), R33.1, R34.2
unnamed: C13.2, IC5.8 (VIN+), R15.1
unnamed: D4.P$2-ANODE, Q4.P$5-D (D), Q4.P$6-D (D), Q4.P$7-D (D), Q4.P$8-D (D), Q4.P$9-D (D), Q4.P$10-D (D), Q4.P$11-D (D)
unnamed: C13.1, IC5.7 (VIN-), R14.1
unnamed: IC10.P$1 (VCC), IC11.5 (VOUT)
unnamed: IC9.P$17 (ALERT|BUSY), R12.2
unnamed: IC10.P$2 (OUT), R29.2, R30.2
unnamed: IC6.1 (OP), Q9.P$4-G (G), R28.1
unnamed: IC6.4 (-IP), R26.1, R27.2
unnamed: IC10.P$4 (CIN2), R29.1, R32.2
unnamed: IC10.P$3 (CIN1), R30.1, R31.2
unnamed: C3.1, IC4.P$7 (RUN/SS)
unnamed: IC10.P$7 (COT2), Q4.P$4-G (G), R39.1
unnamed: C14.1, C19.1, C20.1, H2.36, IC5.5 (VS), IC9.P$2 (VDD), IC9.P$5 (VDD), IC9.P$6 (VREF_IN), R38.2
unnamed: IC4.P$5 (NGATE), Q1.P$4-G (G)
unnamed: C7.1, IC3.P$7 (RUN/SS)
unnamed: IC2.P$1 (SD), IC2.P$8 (DEOC), R18.1, R19.2
unnamed: C2.1, IC4.P$2 (ITH), R4.2
POW_3V3: H1.16, H1.20, IC8.5 (VOUT)
POW_5V: C15.1, C16.1, H1.26, H1.28, IC6.2 (VCC), IC7.2 (VCC), IC8.1 (VIN), IC10.P$9 (RS-), R2.2, R3.2, R11.2, R25.2, R26.2, R28.2, R37.1
POW_9V: C8.+, D2.P$1-CATHODE, H1.22, H1.24, R9.2
POW_RADIO_3V3SYS: H2.27
POW_RADIO_GND: H2.29
POW_RADIO_VBATT: H2.45
Q6_AIN_0: H1.39
Q6_AIN_1: H1.43
Q6_AOUT_0: H1.47
Q6_AOUT_1: H1.51
Q6_GPIO_0: H1.13
Q6_GPIO_2: H2.24
Q6_GPIO_6: H1.7
Q6_GPIO_7: H1.9
Q6_GPIO_8: H1.11
Q6_GPIO_10: H1.50, IC10.P$8 (COT1), R38.1
Q6_GPIO_13: H1.36, Q8.P$4-G (G), R6.1
Q6_GPIO_14: H1.38, Q6.P$4-G (G), R24.1
Q6_GPIO_15: H1.40, IC8.3 (ENA)
Q6_I2C_SCL_1: H2.20, IC5.4 (SCL), IC9.P$19 (SCL)
Q6_I2C_SDA_1: H2.18, IC5.3 (SDA), IC9.P$18 (SDA)
Q6_MAX_RS232: H1.25
Q6_RADIO_UART_RX: H1.18
Q6_RADIO_UART_TX: H1.17
Q6_SPI_CS0: H2.37
Q6_SPI_CS1: H2.25
Q6_SPI_SCLK: H2.21
Q6_SPI_SDI_MISO: H2.35
Q6_SPI_SDO_MOSI: H2.23
SOLAR_PANEL_1_3: H1.29, IC2.P$5 (VIN1), IC2.P$6 (VIN2), R34.1
SOLAR_PANEL_2_4: H1.2, IC1.P$5 (VIN1), IC1.P$6 (VIN2), R36.1
THERMALGND1: H1.5
TOP_TEMP_SOLAR_PANEL-1: H2.1
TOP_TEMP_SOLAR_PANEL-2: H2.3
TOP_TEMP_SOLAR_PANEL-3: H2.5
TOP_TEMP_SOLAR_PANEL-4: H2.7

Notes on the sheet:
POW_RADIO_VBATT
Q6_RADIO_UART_RX
Q6_SPI_SDO_MOSI
Q6_SPI_SDI_MISO
Q6_I2C_SDA_1
Q6_SPI_CS1
GND
ELEC_BAY_TEMP_1
Q6_I2C_SCL_1
Q6_SPI_CS0
MECH_DEPLOY_SWITCH_-V
MECH_DEPLOY_SWITCH_+V
POW_BATT_VOUT
POW_BATT_GND
Q6_GPIO_0
Q6_GPIO_1
Q6_GPIO_2
EXTERNAL_POWER_V+
EXTERNAL_POWER_GND
ANTENNA_DEPLOYMENT_+V
ANTENNA_DEPLOYMENT_GND
SOLAR_PANEL_2_4
3.3V
15V
POW_CONT_1
EXT_PWR
ATTENNA_DEPLOYMENT_1
ATTENNA_DEPLOYMENT_0
SOLAR_PANEL_1_3
3.3V_CTL
ANT_CTL
15V_CTL
POW_RADIO_3.3VSYS
POW_RADIO_GND
Q6_3V3
BATTERY_HEATER_+V
BATTERY_HEATER_-V
BATTERY_THRMSTOR1_+V
BATTERY_THRMSTOR_-V
SLR_PNL_GND

Board: 4 copper layers, 90.5 x 91.8 mm, 84 parts (0 on the bottom side), 57 nets.

## EAGLE design Payload Internal - Auxiliary/Payload v2.1.brd

Parts:
C2: C-USC2012; C2012
H1, H2: ESQ-125-XX-X-D
J30, J31: M80-866XXXX
R3, R4, R8, R9: R-US_R2012; R2012
R10: THERMISTOR-2,5; RS-2,5
U$8: MAX3233; SO20L

Connections:
+3V3: C2.1, H2.36, H2.38, J30.13, R3.2, R4.2, R8.2, R9.2, U$8.9 (VCC), U$8.10 (~FORCEOFF)
ANTENNA_DEPLOYMENT_+V: H1.1, J31.16
ANTENNA_DEPLOYMENT_GND: H1.3, J31.15
BATTERY_HEATER_+V: H1.4
BATTERY_HEATER_-V: H1.6
BATTERY_THRMSTOR2_+V: H1.12
BATTERY_THRMSTOR_+V: H1.8
BATTERY_THRMSTOR_-V: H1.10
BOTTOM_TEMP_SOLAR_PANEL-1: H2.9, J30.5
BOTTOM_TEMP_SOLAR_PANEL-2: H2.11, J30.6
BOTTOM_TEMP_SOLAR_PANEL-3: H2.13, J30.7
BOTTOM_TEMP_SOLAR_PANEL-4: H2.15, J30.8
ELEC_BAY_TEMP_1: H2.50, R10.1
EXTERNAL_POWER_+V: H2.52
EXTERNAL_POWER_GND: H2.51
GND: C2.2, H1.15, H1.19, H1.23, H1.27, H1.34, H1.37, H1.41, H1.44, H1.45, H1.48, H1.49, H1.52, H2.4, H2.16, H2.17, H2.19, H2.22, H2.26, H2.29, H2.30, H2.32, J30.14, U$8.5 (FORCEON), U$8.18 (GND)
MAX_Q6_RS232: H1.21, U$8.7 (T1OUT)
MECH_DEPLOY_SWITCH_+V: H2.31
MECH_DEPLOY_SWITCH_-V: H2.33
PAYGND: J31.9
POW_3V3: H1.20
POW_5V: H1.26, H1.28, H2.45, H2.46, J30.12
POW_9V: H1.22, H1.24, J31.12
POW_BATT_GND: H1.33
POW_BATT_VOUT: H1.35
POW_RADIO_3V3SYS: H1.16, H2.27, H2.28
Q6_AIN_0: H1.39, J31.11
Q6_AIN_1: H1.43
Q6_AOUT_0: H1.47, J31.10
Q6_AOUT_1: H1.51
Q6_GPIO_0: H1.13
Q6_GPIO_2: H2.24
Q6_GPIO_6: H1.7
Q6_GPIO_7: H1.9
Q6_GPIO_8: H1.11
Q6_GPIO_10: H1.32, H1.50
Q6_GPIO_13: H1.36
Q6_GPIO_14: H1.38
Q6_GPIO_15: H1.40
Q6_I2C_SCL_1: H2.20, J30.15, R4.1
Q6_I2C_SDA_1: H2.18, J30.16, R3.1
Q6_MAX_RS232: H1.25, U$8.8 (R1IN)
Q6_RADIO_UART_RX: H1.18, U$8.6 (R1OUT)
Q6_RADIO_UART_TX: H1.17, U$8.4 (T1IN)
Q6_SPI_CS0: H2.14, R9.1
Q6_SPI_CS1: H2.12, R8.1
Q6_SPI_SCLK: H2.21
Q6_SPI_SDI_MISO: H2.35
Q6_SPI_SDO_MOSI: H2.23
SOLAR_PANEL_1_3: H1.29, J31.1
SOLAR_PANEL_2_4: H1.2, J31.3
SOLAR_PANEL_GND_1: H1.30, J31.2
SOLAR_PANEL_GND_2: H1.31, J31.4
THERMALGND1: H1.5, J30.9, R10.2
TOP_TEMP_SOLAR_PANEL-1: H2.1, J30.1
TOP_TEMP_SOLAR_PANEL-2: H2.3, J30.2
TOP_TEMP_SOLAR_PANEL-3: H2.5, J30.3
TOP_TEMP_SOLAR_PANEL-4: H2.7, J30.4

Notes on the sheet:
POW_RADIO_GND
15V_CTL
ANT_CTL
SOLAR_PANEL_2_4
3V3_CTL
POW_RADIO_VBATT

Board: 4 copper layers, 90.5 x 91.8 mm, 11 parts (0 on the bottom side), 32 nets.

## EAGLE design CDH-V3.7/CDH-v3.7.brd

Parts:
ADC_TEMP_1, ADC_TEMP_2: AD7998-1; TSSOP20
C1, C2, C3, C4, C5, C6, C7, C8, C12, C13, C16, C18: 1uF; C2012
C9, C15, C19: 10uF; C2012
C10, C11, C14, C17: 0.1uF; C2012
D1: BB141; SOD523
H1, H2: ESQ-125-XX-X-D
J2: M80-5000000M1-10-331-000; M80-5000000M1
J3: M80-5000000M1-10-331-00-000; M80-5000000M1-04-331-00-000
J4: SMFC; SFMC-107-01-XX-D
R1, R2, R3, R4, R5, R6, R7, R8, R9, R12, R13, R14, R15: 220k; R2012
R10: THERMISTOR-2,5; RS-2,5
R11: 100k; R2012
R16, R17: 10k; R2012
U$4: ADM6316/ADM6320; SOT23-5
U$5: CR1220SMT; CR1220-SMD
U$6: DS3232; SO20L

Connections:
+3V3: ADC_TEMP_1.2 (VDD), ADC_TEMP_1.5 (VDD1), ADC_TEMP_1.16 (~CONVST), ADC_TEMP_2.2 (VDD), ADC_TEMP_2.5 (VDD1), ADC_TEMP_2.16 (~CONVST), C9.1, C10.1, C11.1, C14.1, C15.1, C17.1, H2.36, H2.38, J4.32 (C32), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R12.2, R13.2, R14.2, R15.2, R16.1, R17.2, U$4.5 (VCC), U$6.4 (VCC)
ANTENNA_DEPLOYMENT_+V: H1.1
ANTENNA_DEPLOYMENT_GND: H1.3
BATTERY_HEATER_+V: H1.4, J2.X6
BATTERY_HEATER_-V: H1.6, J2.X7
BATTERY_THRMSTOR2_+V: H1.12, J2.X10
BATTERY_THRMSTOR_+V: H1.8, J2.X8
BATTERY_THRMSTOR_-V: H1.10, J2.X9
BATT_TEMP_0: ADC_TEMP_2.13 (VIN4), C16.2, R13.1
BATT_TEMP_1: ADC_TEMP_2.8 (VIN3), C18.2, J2.X3, R12.1
BOTTOM_TEMP_SOLAR_PANEL-1: ADC_TEMP_1.9 (VIN5), C4.2, H2.9, R5.1
BOTTOM_TEMP_SOLAR_PANEL-2: ADC_TEMP_1.12 (VIN6), C3.2, H2.11, R6.1
BOTTOM_TEMP_SOLAR_PANEL-3: ADC_TEMP_1.10 (VIN7), C2.2, H2.13, R7.1
BOTTOM_TEMP_SOLAR_PANEL-4: ADC_TEMP_1.11 (VIN8), C1.2, H2.15, R8.1
ELEC_BAY_TEMP_0: ADC_TEMP_2.11 (VIN8), C12.2, R10.1, R15.1
ELEC_BAY_TEMP_1: ADC_TEMP_2.10 (VIN7), C13.2, H2.50, R14.1
EXTERNAL_POWER_+V: H2.52, J3.X3
EXTERNAL_POWER_GND: H2.51, J3.X4
GND: ADC_TEMP_1.15 (AS), C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.1, C13.1, C14.2, C15.2, C16.1, C17.2, C18.1, C19.1, D1.A, H1.15, H1.19, H1.23, H1.27, H1.34, H1.37, H1.41, H1.44, H1.45, H1.48, H1.49, H1.52, H2.4, H2.16, H2.17, H2.19, H2.22, H2.26, J4.1 (C1), J4.2 (C2), J4.7 (C7), J4.8 (C8), J4.9 (C9), J4.10 (C10), J4.27 (C27), J4.28 (C28), J4.39 (C39), J4.40 (C40), J4.47 (C47), J4.48 (C48), R9.2, R11.2, U$4.2 (GND), U$5.-, U$6.15 (GND)
MAX_Q6_RS232: H1.21, J4.44 (C44)
MECH_DEPLOY_SWITCH_+V: H2.31, J2.X4
MECH_DEPLOY_SWITCH_-V: H2.33, J2.X5
unnamed: ADC_TEMP_2.15 (AS), R16.2
PA3_GPIO_6: J4.35 (C35)
PA3_GPIO_7: J4.37 (C37)
PA3_GPIO_8: J4.36 (C36)
PA3_GPIO_9: J4.38 (C38)
PA3_JTAG_TCK: J4.29 (C29)
PA3_JTAG_TDI: J4.33 (C33)
PA3_JTAG_TDO: J4.30 (C30)
PA3_JTAG_TMS: J4.31 (C31)
PA3_PC_RS232: J4.41 (C41)
PC_PA3_RS232: J4.43 (C43)
POW_3V3: H1.16, H1.20
POW_5V: H1.26, H1.28, J4.49 (C49), J4.50 (C50)
POW_9V: H1.22, H1.24
POW_BATT_GND: H1.33, J3.X1
POW_BATT_VOUT: H1.35, J3.X2
POW_RADIO_3.3V: H2.27
POW_RADIO_3.3VSYS: H2.28
POW_RADIO_GND: H2.29, H2.30, H2.32
POW_RADIO_VBATT: H2.45, H2.46
PWR_CTRL: J4.45 (C45), R11.1, U$4.1 (~RESET)
Q6_AIN_0: H1.39, J4.3 (C3)
Q6_AIN_1: H1.43, J4.5 (C5)
Q6_AOUT_0: H1.47, J4.4 (C4)
Q6_AOUT_1: H1.51, J4.6 (C6)
Q6_GPIO_0: H1.13, J4.11 (C11), U$4.4 (WDI)
Q6_GPIO_2: H2.24, J4.15 (C15)
Q6_GPIO_6: H1.7, J4.23 (C23)
Q6_GPIO_7: H1.9, J4.25 (C25)
Q6_GPIO_8: H1.11, J4.12 (C12)
Q6_GPIO_10: H1.32, J4.16 (C16)
Q6_GPIO_13: H1.36, J4.22 (C22)
Q6_GPIO_14: H1.38, J4.24 (C24)
Q6_GPIO_15: H1.40, J4.26 (C26)
Q6_I2C_SCL_1: ADC_TEMP_1.19 (SCL), ADC_TEMP_2.19 (SCL), H2.20, J4.13 (C13), U$6.18 (SCL)
Q6_I2C_SDA_1: ADC_TEMP_1.18 (SDA), ADC_TEMP_2.18 (SDA), H2.18, J4.14 (C14), U$6.17 (SDA)
Q6_MAX_RS232: H1.25, J4.42 (C42)
Q6_RADIO_UART_RX: H1.18
Q6_RADIO_UART_TX: H1.17
Q6_SPI_CS0: H2.37, J4.20 (C20)
Q6_SPI_CS1: H2.25, J4.21 (C21)
Q6_SPI_SCLK: H2.21, J4.17 (C17)
Q6_SPI_SDI_MISO: H2.35, J4.19 (C19)
Q6_SPI_SDO_MOSI: H2.23, J4.18 (C18)
REF_IN: ADC_TEMP_1.6 (REF_IN), ADC_TEMP_2.6 (REF_IN), C19.2, D1.C, R17.1
SOLAR_PANEL_1_3: H1.29
SOLAR_PANEL_2_4: H1.2
SOLAR_PANEL_GND: H1.30, H1.31
THERMALGND1: ADC_TEMP_1.1 (AGND), ADC_TEMP_1.3 (AGND1), ADC_TEMP_1.4 (AGND2), ADC_TEMP_1.20 (AGND3), ADC_TEMP_2.1 (AGND), ADC_TEMP_2.3 (AGND1), ADC_TEMP_2.4 (AGND2), ADC_TEMP_2.20 (AGND3), H1.5, R9.1, R10.2
TOP_TEMP_SOLAR_PANEL-1: ADC_TEMP_1.7 (VIN1), C8.2, H2.1, R1.1
TOP_TEMP_SOLAR_PANEL-2: ADC_TEMP_1.14 (VIN2), C7.2, H2.3, R2.1
TOP_TEMP_SOLAR_PANEL-3: ADC_TEMP_1.8 (VIN3), C6.2, H2.5, R3.1
TOP_TEMP_SOLAR_PANEL-4: ADC_TEMP_1.13 (VIN4), C5.2, H2.7, R4.1
VBAT: U$5.+$1 (+), U$5.+$2 (+1), U$6.16 (VBAT)
~MANUAL_RESET: U$4.3 (~MR)
~PA3_JTAG_TRST: J4.34 (C34)
~WAKE_UP: J4.46 (C46)

Notes on the sheet:
POW_RADIO_GND
Q6_AOUT_0
Q6_AOUT_1
SOLAR PANEL TEMP SENSORS
BATTERY / ELEC BAY / COMMS / PAYLOAD TEMP SENSORS
ELEC_BAY_TEMP_0
ELEC_BAY_TEMP_1
PAY_TEMP_0
PAY_TEMP_1
BATT_TEMP_0
BATT_TEMP_1
COMMS_ATTENA_TEMP
Q6-Connector
15V_CTL
ANT_CTL
SOLAR_PANEL_2_4
3V3_CTL
WATCH_DOG_INPUT

Board: 4 copper layers, 90.6 x 91.8 mm, 47 parts (0 on the bottom side), 58 nets.

File CDH-V3.7/CDH-v3.7 bom.csv:

"Part";"Value";"Device";"Package";"Description";"";
"ADC_TEMP_1";"AD7998-1";"AD7998-1";"TSSOP20";"";"";
"ADC_TEMP_2";"AD7998-1";"AD7998-1";"TSSOP20";"";"";
"C1";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C2";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C3";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C4";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C5";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C6";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C7";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C8";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C9";"10uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C10";"0.1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C11";"0.1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C12";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C13";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C14";"0.1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C15";"10uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C16";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C17";"0.1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C18";"1uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"C19";"10uF";"C-EUC2012";"C2012";"CAPACITOR, European symbol";"";
"D1";"BB141";"BB141";"SOD523";"Capacity DIODE";"";
"H1";"ESQ-125-XX-X-D";"ESQ-125-XX-X-D";"ESQ-125-XX-X-D";"ELEVATED SOCKET, .100 inch(2.54mm) PITCH";"";
"H2";"ESQ-125-XX-X-D";"ESQ-125-XX-X-D";"ESQ-125-XX-X-D";"ELEVATED SOCKET, .100 inch(2.54mm) PITCH";"";
"R1";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R2";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R3";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R4";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R5";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R6";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R7";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R8";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R9";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R10";"THERMISTOR-2,5";"THERMISTOR-2,5";"RS-2,5";"THERMISTOR";"";
"R11";"100k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R12";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R13";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R14";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R15";"220k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R16";"10k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"R17";"10k";"R-US_R2012";"R2012";"RESISTOR, American symbol";"";
"U$1";"SMFC";"SMFC";"SFMC-107-01-XX-D";"";"";
"U$2";"M80-5000000M1-10-331-000";"M80-5000000M1-10-331-000";"M80-5000000M1";"";"";
"U$3";"M80-5000000M1-10-331-00-000";"M80-5000000M1-10-331-00-000";"M80-5000000M1-04-331-00-000";"";"";
"U$4";"ADM6316/ADM6320";"ADM6316/ADM6320";"SOT23-5";"";"";
"U$5";"";"CR1220SMT";"CR1220-SMD";"CR1216/CR1220/CR1225 12mm 3V lithium coin cell";"";
"U$6";"DS3232";"DS3232";"SO20L";"";"";
