# Repository spaceconcordia/Consat1Electrical (continued)

## EAGLE design ACS/ACS_PCB.brd

Parts:
C1: .1uF; 0402-CAP
C2: .22uF; 0402-CAP
C3: 4.7uF; 0402-CAP
J1: M80-879
R1, R2: DNP; 0402-RES
U1: HMC5883LSMD; 16LPCC

Connections:
+3V3: C1.1, J1.2, R1.2, R2.2, U1.2 (VDD), U1.4 (S1), U1.13 (VDDIO)
GND: C1.2, C3.2, J1.1, U1.9 (GND), U1.11 (GND)
unnamed: C3.1, U1.10 (C1)
unnamed: C2.1, U1.8 (SETP)
unnamed: C2.2, U1.12 (SETC)
Q6_I2C_SCL_1: J1.4, R1.1, U1.1 (SCL)
Q6_I2C_SDA_1: J1.3, R2.1, U1.16 (SDA)

Notes on the sheet:
Jordan McConnell

Board: 2 copper layers, 93.7 x 37.8 mm, 7 parts (0 on the bottom side), 7 nets.

File ACS/ACS PCB bom.csv:

"Part";"Value";"Device";"Package";"Description";"";
"C1";".1uF";"CAP0402-CAP";"0402-CAP";"Capacitor";"";
"C2";".22uF";"CAP0402-CAP";"0402-CAP";"Capacitor";"";
"C3";"4.7uF";"CAP0402-CAP";"0402-CAP";"Capacitor";"";
"JP1";"";"M80-879";"M80-879";"";"";
"R1";"DNP";"RESISTOR0402-RES";"0402-RES";"Resistor";"";
"R2";"DNP";"RESISTOR0402-RES";"0402-RES";"Resistor";"";
"U1";"HMC5883LSMD";"HMC5883LSMD";"16LPCC";"3 Axis Digital Compass IC";"";

## EAGLE design CDH/CDH-v4.11-A-DS1338-tcc-test-redesign.brd

Parts:
ADC_TEMP_1, ADC_TEMP_2: AD7998-1; TSSOP20
C1, C2, C3, C5, C13: 0.1uF; C2012
C4, C6, C11: 10uF; C2012
C7, C8, C9, C10, C12, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24: 1uF; C2012
D1: ZENER-DIODESOD80C; SOD80C
H1, H2: ESQ-125-XX-X-D
Q1: CRYSTALTC38H; TC38H
R1: 100k; R2012
R2, R3, R6: 10k; R2012
R4, R5, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: 220k; R2012
R22: THERMISTOR-2,5; RS-2,5
U1: DS1338Z-33+; SOIC127P600X175-8N
U$1: M80-5000000M1-10-331-00-000; M80-5000000M1-04-331-00-000
U$2: M80-5000000M1-10-331-000; M80-5000000M1
U$3: ADM6316/ADM6320; SOT23-5
U$4: SMFC; SFMC-107-01-XX-D
U$6: CR1220SMT; CR1220-SMD

Connections:
+3V3: ADC_TEMP_1.2 (VDD), ADC_TEMP_1.5 (VDD1), ADC_TEMP_1.16 (~CONVST), ADC_TEMP_2.2 (VDD), ADC_TEMP_2.5 (VDD1), ADC_TEMP_2.16 (~CONVST), C2.1, C5.1, C6.1, C11.1, C13.1, H2.36, H2.38, R2.2, R3.1, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, U1.7 (VCC), U$4.32 (C32)
ANTENNA_DEPLOYMENT_+V: H1.1
ANTENNA_DEPLOYMENT_GND: H1.3
BATTERY_HEATER_+V: H1.4, U$2.X6
BATTERY_HEATER_-V: H1.6, U$2.X7
BATTERY_THRMSTOR2_+V: H1.12, U$2.X10
BATTERY_THRMSTOR_+V: H1.8, U$2.X8
BATTERY_THRMSTOR_-V: H1.10, U$2.X9
BATT_TEMP_0: ADC_TEMP_1.13 (VIN4), C20.2, R16.1
BATT_TEMP_1: ADC_TEMP_1.8 (VIN3), C21.2, R15.1, U$2.X3
BOTTOM_TEMP_SOLAR_PANEL-1: ADC_TEMP_2.14 (VIN2), C15.2, H2.9, R5.1
BOTTOM_TEMP_SOLAR_PANEL-2: ADC_TEMP_2.13 (VIN4), C12.2, H2.11, R8.1
BOTTOM_TEMP_SOLAR_PANEL-3: ADC_TEMP_2.12 (VIN6), C9.2, H2.13, R10.1
BOTTOM_TEMP_SOLAR_PANEL-4: ADC_TEMP_2.11 (VIN8), C7.2, H2.15, R12.1
ELEC_BAY_TEMP_0: ADC_TEMP_1.11 (VIN8), C16.2, R20.1, R22.1
EXTERNAL_POWER_+V: H2.51, U$1.X4
EXTERNAL_POWER_GND: H2.52, U$1.X3
GND: ADC_TEMP_2.15 (AS), C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.1, C8.1, C9.1, C10.1, C11.2, C12.1, C13.2, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, D1.A, H1.15, H1.19, H1.23, H1.27, H1.34, H1.37, H1.41, H1.44, H1.45, H1.48, H1.49, H1.52, H2.4, H2.16, H2.17, H2.19, H2.22, H2.26, R1.2, R21.2, U1.4 (GND), U$3.2 (GND), U$4.1 (C1), U$4.2 (C2), U$4.7 (C7), U$4.8 (C8), U$4.9 (C9), U$4.10 (C10), U$4.27 (C27), U$4.28 (C28), U$4.39 (C39), U$4.40 (C40), U$4.47 (C47), U$4.48 (C48), U$6.-
MECH_DEPLOY_SWITCH_+V: H2.31, U$2.X4
MECH_DEPLOY_SWITCH_-V: H2.33, U$2.X5
unnamed: ADC_TEMP_1.15 (AS), R3.2
unnamed: R2.1, U1.8 (SQW/OUT)
unnamed: U1.3 (VBAT), U$6.+$1 (+), U$6.+$2 (+1)
unnamed: Q1.1, U1.1 (X1)
unnamed: Q1.2, U1.2 (X2)
PA3_GPIO_6: U$4.35 (C35)
PA3_GPIO_7: U$4.37 (C37)
PA3_GPIO_8: U$4.36 (C36)
PA3_GPIO_9: U$4.38 (C38)
PA3_JTAG_TCK: U$4.29 (C29)
PA3_JTAG_TDI: U$4.33 (C33)
PA3_JTAG_TDO: U$4.30 (C30)
PA3_JTAG_TMS: U$4.31 (C31)
PA3_PC_RS232: H1.25, U$4.41 (C41)
PAYLOAD_TEMP: ADC_TEMP_1.10 (VIN7), C17.2, H2.50, R19.1
PC_PA3_RS232: H1.21, U$4.43 (C43)
PC_Q6_RS232: U$2.X2, U$4.44 (C44)
POW_3V3: H1.16, H1.20
POW_5V: C1.1, H1.26, H1.28, U$3.5 (VCC), U$4.49 (C49), U$4.50 (C50)
POW_9V: H1.22, H1.24
POW_BATT_GND: H1.33, U$1.X1
POW_BATT_VOUT: H1.35, U$1.X2
POW_RADIO_3.3V: H2.27
POW_RADIO_3.3VSYS: H2.28
POW_RADIO_GND: H2.29, H2.30, H2.32
POW_RADIO_VBATT: H2.45, H2.46
PWR_CTRL: R1.1, U$3.1 (~RESET), U$4.45 (C45)
Q6_AIN_0: H1.39, U$4.3 (C3)
Q6_AIN_1: H1.43, U$4.5 (C5)
Q6_AOUT_0: H1.47, U$4.4 (C4)
Q6_AOUT_1: H1.51, U$4.6 (C6)
Q6_GPIO_0: H1.13, U$3.4 (WDI), U$4.11 (C11)
Q6_GPIO_2: H2.24, U$4.15 (C15)
Q6_GPIO_6: H1.7, U$4.23 (C23)
Q6_GPIO_7: H1.9, U$4.25 (C25)
Q6_GPIO_8: H1.11, U$4.12 (C12)
Q6_GPIO_10: H1.32, U$4.16 (C16)
Q6_GPIO_13: H1.36, U$4.22 (C22)
Q6_GPIO_14: H1.38, U$4.24 (C24)
Q6_GPIO_15: H1.40, U$4.26 (C26)
Q6_I2C_SCL_1: ADC_TEMP_1.19 (SCL), ADC_TEMP_2.19 (SCL), H2.20, U1.6 (SCL), U$4.13 (C13)
Q6_I2C_SDA_1: ADC_TEMP_1.18 (SDA), ADC_TEMP_2.18 (SDA), H2.18, U1.5 (SDA), U$4.14 (C14)
Q6_PC_RS232: U$2.X1, U$4.42 (C42)
Q6_RADIO_UART_RX: H1.18
Q6_RADIO_UART_TX: H1.17
Q6_SPI_CS0: H2.14, U$4.20 (C20)
Q6_SPI_CS1: H2.12, U$4.21 (C21)
Q6_SPI_SCLK: H2.6, U$4.17 (C17)
Q6_SPI_SDI_MISO: H2.10, U$4.19 (C19)
Q6_SPI_SDO_MOSI: H2.8, U$4.18 (C18)
REF_IN: ADC_TEMP_1.6 (REF_IN), ADC_TEMP_2.6 (REF_IN), C3.1, C4.2, D1.C, R6.1
SLR_PNL_GND: H1.30
SOLAR_PANEL_1_3: H1.29
SOLAR_PANEL_2_4: H1.2
SOLAR_PANEL_GND: H1.31
TEMP_SENSOR2: ADC_TEMP_1.9 (VIN5), C19.2, R17.1
TEMP_SENSOR_0: ADC_TEMP_1.7 (VIN1), C23.2, R13.1
TEMP_SENSOR_1: ADC_TEMP_1.14 (VIN2), C22.2, R14.1
TEMP_SENSOR_3: ADC_TEMP_1.12 (VIN6), C18.2, R18.1
THERMALGND1: ADC_TEMP_1.1 (AGND), ADC_TEMP_1.3 (AGND1), ADC_TEMP_1.4 (AGND2), ADC_TEMP_1.20 (AGND3), ADC_TEMP_2.1 (AGND), ADC_TEMP_2.3 (AGND1), ADC_TEMP_2.4 (AGND2), ADC_TEMP_2.20 (AGND3), H1.5, R21.1, R22.2
TOP_TEMP_SOLAR_PANEL-1: ADC_TEMP_2.7 (VIN1), C24.2, H2.1, R4.1
TOP_TEMP_SOLAR_PANEL-2: ADC_TEMP_2.8 (VIN3), C14.2, H2.3, R7.1
TOP_TEMP_SOLAR_PANEL-3: ADC_TEMP_2.9 (VIN5), C10.2, H2.5, R9.1
TOP_TEMP_SOLAR_PANEL-4: ADC_TEMP_2.10 (VIN7), C8.2, H2.7, R11.1
~MANUAL_RESET: U$3.3 (~MR)
~PA3_JAG_TRST: U$4.34 (C34)
~WAKE_UP: U$4.46 (C46)

Notes on the sheet:
POW_RADIO_GND
Q6_AOUT_0
Q6_AOUT_1
SOLAR PANEL TEMP SENSORS
BATTERY / ELEC BAY / COMMS / PAYLOAD TEMP SENSORS
Q6-Connector
15V_CTL
ANT_CTL
SOLAR_PANEL_2_4
3V3_CTL
Q6_GPIO_10
WATCH_DOG_INPUT

Board: 4 copper layers, 90.6 x 91.8 mm, 58 parts (2 on the bottom side), 66 nets.

## EAGLE design Payload Internal - Auxiliary/Auxiliary-Payload v4.2.brd

Parts:
C1: 100 nF; C0603-ROUND
C2: 0.1 uF; C2012
C3, C6, C10, C11, C29, C33, C36: 10 uF; C1210
C4, C5: 22 pF; C0603-ROUND
C7: 10 uF; C1206
C8, C9, C12, C13, C14, C15, C16, C17, C18, C21, C28, C31, C35: 0.1 uF; C0603
C19, C26, C27, C32, C34: 51 pF; C0603
C20, C22, C23, C24, C25: 10 uF; C/6032-28W
C30: 15 pF; C0603
D1: CD1206-SO1575; MINIMELF
H1, H2: ESQ-125-XX-X-D
IC2: ATMEGA328P-AU; TQFP32-08
JP1: PINHD-2X3; 2X03
R1: R-EU_0603-RND; R0603-ROUND
R2, R7: 1 kOhm; R1206
R3, R4, R8, R9: 4.7 kOhm; R2012
R5, R11: 1 MOhm; R2010
R6, R12: 36 Ohm; R2010
R10: THERMISTOR-2,5; RS-2,5
R13, R14: 100 kOhm; R0805
R15: 178 Ohm; R1206
R16: 1.4 MOhm; R1206
R17, R19, R22: 1 kOhm; R0805
R18, R20: 1.5 MOhm; R0805
R21, R23, R24, R25, R26, R27, R28, R29, R30: 100 Ohm; R0603
R31: 10 kOhm; R0603
R32, R33: 500 Ohm; R0805
R34: 3.5 MOhm; R1206
R35: 178 Ohm; R1210
U1: AD7294BSUZ; SU_64_1
U$1, U$3: M80-866XXXX
U$2, U$4: FZT651-NPN-TRANSISTOR; SOT223-PZT3904
U$5: CSM-7X-DU-CRYSTAL-ARDUINO; CSM-7X-DU-CRYSTAL
U$6: 74LVC1G18-SOT363; SOT-363
U$8: MAX3233; SO20L
U$26, U$29, U$30: CONNECTOR-3; CONNECTOR-3T
U$31, U$33, U$34, U$36: CONNECTOR-SHORT; CONNECTOR-T
U$38: ADG3304BRUZ; RU_14

Connections:
9V: H1.22, H1.24, U$1.12
+3V3: C2.1, C31.1, C33.1, H2.36, H2.38, R3.2, R4.2, R8.2, R9.2, U$3.13, U$8.9 (VCC), U$8.10 (~FORCEOFF), U$38.1 (VCCA), U$38.8 (EN)
A: R34.2, R35.2, U$6.P$3 (A)
AD0: IC2.23 ((ADC0)PC0))
AD2: IC2.25 ((ADC2)PC2), R17.1, R18.1
AD3: IC2.26 ((ADC3)PC3), R19.1, R20.1
AD4/SDA: IC2.27 ((ADC4)PC4), U$29.P$1 (1)
AD5/SCI: IC2.28 ((ADC5)PC5), U$30.P$1 (1)
AGND_ADC: C3.2, C6.2, C7.2, C8.2, C9.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.-, C21.2, C22.-, C25.-, U1.6 (AGND1), U1.7 (AGND2), U1.13 (AGND3), U1.20 (DACOUTGNDAB), U1.24 (AGND4), U1.29 (DACOUTGNDCD), U1.34 (AGND5), U1.55 (AGND6), U1.58 (AGND7), U$26.P$1 (1)
ALERT/BUSY: R22.1, U1.35 (ALERT/BUSY)
ANTENNA_DEPLOYMENT_+V: H1.1, U$1.16
ANTENNA_DEPLOYMENT_GND: H1.3, U$1.15
AREF: IC2.20 (AREF)
BATTERY_HEATER_+V: H1.4
BATTERY_HEATER_-V: H1.6
BATTERY_THERMSTOR_2+: H1.12
BATTERY_THRMSTOR_+V: H1.8
BATTERY_THRMSTOR_-V: H1.10
BOTTOM_TEMP_SOLAR_PANEL-1: H2.9, U$3.5
BOTTOM_TEMP_SOLAR_PANEL-2: H2.11, U$3.6
BOTTOM_TEMP_SOLAR_PANEL-3: H2.13, U$3.7
BOTTOM_TEMP_SOLAR_PANEL-4: H2.15, U$3.8
D1(+): R25.2
D1(-): R26.1
D1+: C23.+, R25.1, U1.11 (D1+)
D1-: C23.-, R26.2, U1.12 (D1-)
D2(+): R27.2
D2(-): R28.1
D2+: C24.+, R27.1, U1.10 (D2+)
D2-: C24.-, R28.2, U1.9 (D2-)
DCAP: C18.1, U1.54 (DCAP)
DEMUX_VCC: C35.2, C36.2, U$6.P$5 (VCC)
DGND_ADC: U1.36 (AS2), U1.37 (AS1), U1.38 (AS0), U1.41 (OPGND), U1.43 (DGND), U1.47 (DGND_2), U1.48 (DGND_3), U$26.P$3 (3)
ELEC_BAY_TEMP_1: H2.50, R10.1
EXTERNAL_POWER_+V: H2.51
EXTERNAL_POWER_GND: H2.52
FACTORY_TEST: R24.2, U1.14 (FACTORY_TEST)
G-M-COUNTS: R15.2, U$1.10
G-M-OUTPUT-AMPLITUDE: IC2.24 ((ADC1)PC1), U$1.5
GND: H1.15, H1.19, H1.23, H1.27, H1.34, H1.37, H1.41, H1.44, H1.45, H1.48, H1.49, H1.52, H2.4, H2.16, H2.17, H2.19, H2.22, H2.26, H2.29, H2.30, H2.32, U$3.14, U$31.P$1 (IN), U$33.P$1 (IN), U$34.P$1 (IN), U$36.P$1 (IN)
GND1: C1.2, C2.2, C4.2, C5.2, C10.2, C11.2, C19.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.2, C34.2, IC2.5 (GND), IC2.21 (AGND), JP1.6, R5.1, R6.1, R11.1, R12.1, R18.2, R20.2, R32.2, R33.1, R34.1, U$1.9, U$6.P$2 (GND), U$8.5 (FORCEON), U$8.18 (GND), U$26.P$2 (2), U$31.P$2 (OUT), U$33.P$2 (OUT), U$38.7 (GND)
GND2: U$3.11, U$34.P$2 (OUT)
GND3: R16.2, U$3.10, U$36.P$2 (OUT)
HV_OUTPUT1: R17.2, U$1.6
HV_OUTPUT2: R19.2, U$1.7
IO0: IC2.30 ((RXD)PD0)
IO1: IC2.31 ((TXD)PD1)
IO2: IC2.32 ((INT0)PD2), R15.1, R16.1
IO3: IC2.1 ((INT1)PD3), R35.1
IO4: IC2.2 ((T0)PD4)
IO5: IC2.9 ((T1)PD5)
IO6: IC2.10 ((AIN0)PD6)
IO7: IC2.11 ((AIN1)PD7)
IO8: IC2.12 ((ICP)PB0)
IO9: IC2.13 ((OC1)PB1), U$6.P$1 (S)
ISENSE1OVERRANGE: U1.46 (ISENSE1OVERRANGE)
ISENSE2OVERRANGE: U1.45 (ISENSE2OVERRANGE)
MECH_DEPLOY_SWITCH_+V: H2.31
MECH_DEPLOY_SWITCH_-V: H2.33
unnamed: IC2.16 ((MISO)PB4), JP1.1, U$38.13 (Y1)
unnamed: C30.1, H2.35, U$38.2 (A1)
unnamed: H2.37, U$38.5 (A4)
unnamed: R7.2, U$4.P$2 (B)
unnamed: C4.1, IC2.7 (XTAL1), R1.1, U$5.P$2 (2)
unnamed: C5.1, IC2.8 (XTAL2), R1.2, U$5.P$1 (1)
unnamed: C27.1, IC2.15 ((MOSI)PB3), JP1.4, U$38.12 (Y2)
unnamed: R2.2, U$2.P$2 (B)
unnamed: H2.21, U$38.4 (A3)
unnamed: H2.23, U$38.3 (A2)
NC: H1.39
NC1: H1.47
NC_1: U1.1 (NC_1)
NC_2: U1.4 (NC_2)
NC_3: R29.1, U1.5 (NC_3)
NC_4: R30.1, U1.8 (NC_4)
NC_5: U1.16 (NC_5)
NC_6: U1.17 (NC_6)
NC_7: R23.1, U1.25 (NC_7)
NC_8: U1.32 (NC_8)
NC_9: U1.33 (NC_9)
NC_10: R21.2, U1.57 (NC_10)
NC_11: U1.59 (NC_11)
NC_12: U1.64 (NC_12)
OFFSETINA: C12.1, U1.18 (OFFSETINA)
OFFSETINB: C13.1, U1.23 (OFFSETINB)
OFFSETINC: C16.1, U1.26 (OFFSETINC)
OFFSETIND: C17.1, U1.31 (OFFSETIND)
PC_Q6_RS232: H1.21, U$8.7 (T1OUT)
POW_3V3: H1.20
POW_5V: C1.1, C3.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C14.1, C15.1, C20.+, C21.1, C28.1, C29.1, C35.1, C36.1, D1.C, H1.26, H1.28, H2.45, H2.46, IC2.4 (VCC), IC2.18 (AVCC), JP1.2, R21.1, R22.2, R23.2, R24.1, R29.2, R30.2, R31.2, U1.21 (DACOUTV+AB), U1.28 (DACOUTV+CD), U1.42 (VDRIVE), U1.44 (RESET), U1.56 (AVDD), U$2.P$1 (C), U$3.12, U$4.P$1 (C), U$29.P$2 (2), U$30.P$2 (2), U$38.14 (VCCY)
POW_BATT_GND: H1.33
POW_BATT_VOUT: H1.35
POW_RADIO_3.3V: H1.16, H2.27, H2.28
PULSE1: C32.2, R32.1, U$1.13, U$6.P$6 (1Y)
PULSE2: C34.1, R33.2, U$1.11, U$6.P$4 (2Y)
Q6_AIN_1: H1.43
Q6_AOUT_1: H1.51
Q6_GPIO_0: H1.13
Q6_GPIO_2: H2.24
Q6_GPIO_6: H1.7
Q6_GPIO_7: H1.9
Q6_GPIO_8: H1.11
Q6_GPIO_10: H1.32
Q6_GPIO_11: H1.50
Q6_GPIO_13: H1.36
Q6_GPIO_14: H1.38
Q6_GPIO_15: H1.40
Q6_I2C_SCL_1: H2.20, R4.1, U$3.15
Q6_I2C_SDA_1: H2.18, R3.1, U$3.16
Q6_PC_RS232: H1.25, U$8.8 (R1IN)
Q6_RADIO_UART_RX: H1.18, U$8.6 (R1OUT)
Q6_RADIO_UART_TX: H1.17, U$8.4 (T1IN)
Q6_SPI_CS0: H2.14, R9.1
Q6_SPI_CS1: H2.12, R8.1
Q6_SPI_SCLK: H2.6
Q6_SPI_SDI_MISO: H2.10
Q6_SPI_SDO_MOSI: H2.8
REFOUT/REFINADC: C25.+, U1.53 (REFOUT/REFINADC)
REFOUT/REFINDAC: C22.+, U1.15 (REFOUT/REFINDAC)
RESET: D1.A, IC2.29 (RESET), JP1.5, R31.1
RS1+: R14.1, U1.60 (RS1+), U1.62 (VPP1)
RS1-: R14.2, U1.61 (RS1-)
RS2+: R13.1, U1.3 (RS2+), U1.63 (VPP2)
RS2-: R13.2, U1.2 (RS2-)
SCK: C19.1, IC2.17 ((SCK)PB5), JP1.3, U$38.11 (Y3)
SCL: U1.40 (SCL), U$30.P$3 (3)
SDA: U1.39 (SDA), U$29.P$3 (3)
SOLAR_PANEL_1_3: H1.29, U$1.1
SOLAR_PANEL_2_4: H1.2, U$1.3
SOLAR_PANEL_GND_1: H1.30, U$1.2
SOLAR_PANEL_GND_2: H1.31, U$1.4
SS: C26.1, IC2.14 ((SS)PB2), U$38.10 (Y4)
THERMALGND: H1.5, R10.2, U$3.9
TOP_TEMP_SOLAR_PANEL-1: H2.1, U$3.1
TOP_TEMP_SOLAR_PANEL-2: H2.3, U$3.2
TOP_TEMP_SOLAR_PANEL-3: H2.5, U$3.3
TOP_TEMP_SOLAR_PANEL-4: H2.7, U$3.4
VIN0: U1.52 (VIN0)
VIN1: U1.51 (VIN1)
VIN2: U1.50 (VIN2)
VIN3: U1.49 (VIN3)
VOLTAGE_SWEEP1: R6.2, U$1.8, U$2.P$4 (E)
VOLTAGE_SWEEP2: R12.2, U$1.14, U$4.P$4 (E)
VOUTA: R2.1, R5.2, U1.19 (VOUTA)
VOUTB: R7.1, R11.2, U1.22 (VOUTB)
VOUTC: U1.27 (VOUTC)
VOUTD: U1.30 (VOUTD)

Notes on the sheet:
POW_RADIO_GND
15V_CTL
ANT_CTL
SOLAR_PANEL_2_4
3V3_CTL
POW_RADIO_VBATT
Crystal at 16 MHz
VDAC=+5V power

Board: 4 copper layers, 90.5 x 91.8 mm, 92 parts (0 on the bottom side), 89 nets.
